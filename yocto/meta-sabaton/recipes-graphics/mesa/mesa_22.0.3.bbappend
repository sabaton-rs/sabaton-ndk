PACKAGECONFIG:append = "v3d virgl gallium vulkan broadcom"