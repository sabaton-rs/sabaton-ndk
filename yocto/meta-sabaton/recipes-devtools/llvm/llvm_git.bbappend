PV = "15.0.6"
SRCREV="088f33605d8a61ff519c580a71b1dd57d16a03f8"
EXTRA_OECMAKE += " -DCMAKE_BUILD_TYPE=RelWithDebInfo "
DEPENDS += " zstd "
