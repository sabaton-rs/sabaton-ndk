include cyclonedds.inc

SRC_URI = "git://github.com/eclipse-cyclonedds/cyclonedds.git;protocol=git;tag=0.8.0rc1"

