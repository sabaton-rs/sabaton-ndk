include cyclonedds.inc
LICENSE = "Eclipse-2"
SRC_URI = "https://github.com/eclipse-cyclonedds/cyclonedds.git;branch=releases/0.9.x;tag=0.9.0"
LIC_FILES_CHKSUM = "file://${WORKDIR}/git/LICENSE;md5=ca2dafd1f07f3cd353d0454d3c4d9e80"
SRC_URI[sha256sum] = "4006024c042464ab6ad589e9477c9fa1be6a797a11214f79de8942033e0ade0d"



