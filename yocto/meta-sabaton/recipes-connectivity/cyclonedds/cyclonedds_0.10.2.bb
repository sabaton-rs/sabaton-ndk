include cyclonedds.inc
LICENSE = "Eclipse-2"
SRC_URI = "git://github.com/eclipse-cyclonedds/cyclonedds.git;protocol=https;branch=releases/0.10.x"
SRCREV = "9995905bce6c4cf9f740d6438bbf7fcfd1c83dfd"
LIC_FILES_CHKSUM = "file://${WORKDIR}/git/LICENSE;md5=ca2dafd1f07f3cd353d0454d3c4d9e80"



