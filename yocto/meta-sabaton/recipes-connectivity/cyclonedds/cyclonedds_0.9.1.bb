include cyclonedds.inc
LICENSE = "Eclipse-2"
SRC_URI = "git://github.com/eclipse-cyclonedds/cyclonedds.git;protocol=https;branch=releases/0.9.x"
SRCREV="3919eab58a2ea5fb46e27caaf86d879dbac90eb0"
LIC_FILES_CHKSUM = "file://${WORKDIR}/git/LICENSE;md5=ca2dafd1f07f3cd353d0454d3c4d9e80"



