## Enable selinux for systemd even though the distro doesn't use it

require ${BPN}_selinux.inc
